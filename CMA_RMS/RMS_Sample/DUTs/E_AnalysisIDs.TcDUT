TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_RMS,
	eID_Sink
	
) UDINT;
END_TYPE
